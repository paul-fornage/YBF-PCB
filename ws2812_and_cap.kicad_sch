File: ws2812_and_cap.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: Hieracrchical PCB
Parts:
- renumbered C1 to C9
Connections:
- net VCC_IN renamed VIN
